# Keil uVision project app.uvprojx, settings and files
target Iot (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER,USER_VECT_TAB_ADDRESS
  c include: ..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\FreeRTOS\include;..\..\Drivers;..\..\Core\Inc;..\..\BSP\Inc;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Core;..\..\Middlewares;..\..\BSP;..\..\App\Onenet;..\..\App\ota;..\..\App;..\..\Middlewares\MQTT
  memory RVCT4: ROM 0x800c000 size 0x3a000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Core
    ../../Core/Src/: stm32f1xx_it.c main.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group BSP
    ../../BSP/Src/: key.c led.c socket.c w5500.c spi.c wizchip_conf.c tcp_client.c lcd.c dht11.c transport.c w5500_port.c beep.c
  group App\Task
    ../../App/: freertos_task.c fw_info.c
  group App\Onenet
    ../../App/Onenet/: onenet.c
  group App\ota
    ../../App/ota/: ota_download.c
  group Drivers\SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers\STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_adc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_spi.c stm32f1xx_ll_usart.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group FreeRTOS_CORE
    ../../FreeRTOS/: tasks.c queue.c timers.c croutine.c event_groups.c list.c stream_buffer.c
  group FreeRTOS_PORT
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Middlewares\MQTT
    ../../Middlewares/MQTT/: mqtt_client.c mqtt_wrapper.c
  group Middlewares\cJSON
    ../../Middlewares/cJSON/: cJSON.c
